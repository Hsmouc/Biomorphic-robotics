# IAR project tiaoshi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: src\projects; src\LIB\CMSIS; src\LIB\FatFs; src\app; src\drivers\LED; src\common; src\cpu; src\cpu\headers; src\platforms; src\drivers; src\drivers\adc; src\drivers\exti; src\drivers\dma; src\drivers\camera; src\drivers\delay; src\drivers\FTM; src\drivers\gpio; src\drivers\i2c; src\drivers\lptmr; src\drivers\mcg; src\drivers\PIT; src\drivers\pmc; src\drivers\rtc; src\drivers\uart; src\drivers\wdog; src\drivers\oled; src\drivers\PCA9685; src\drivers\servo; src\drivers\iic; src\drivers\spi; src\drivers\NRF24L0; src\drivers\AT24C1024; src\drivers\mpu6050; src\drivers\dmp; build
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: tiaoshi.out
  ILINK.IlinkIcfFile: build\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    src/app/: isr.c
    src/projects/: main.c
  group common
    src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    src/drivers/adc/: adc0.c
    src/drivers/AT24C1024/: AT24C1024.c
    src/drivers/camera/: D_SCCB.c OV7725.c
    src/drivers/delay/: delay.c
    src/drivers/dma/: dma.c
    src/drivers/exti/: exti.c
    src/drivers/mpu6050/: getattitude.c MPU6050.c
    src/drivers/gpio/: gpio.c init_GPIO.c
    src/drivers/iic/: iic.c iic2.c
    src/drivers/dmp/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    src/drivers/LED/: LED.C
    src/drivers/lptmr/: lptmr.c
    src/drivers/mcg/: mcg.c
    src/drivers/NRF24L0/: NRF24L01.c
    src/drivers/PCA9685/: pca9685.c
    src/drivers/PIT/: PIT.c
    src/drivers/servo/: servo.c
    src/drivers/spi/: spi.c
    src/drivers/uart/: uart.c
    src/drivers/wdog/: wdog.c
  group header
    src/common/: common.h
    src/app/: include.h isr.h
    src/platforms/: k60_fire.h
